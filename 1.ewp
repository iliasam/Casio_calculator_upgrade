# IAR project 1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD_VL; HAVE_CONFIG_H; HSE_VALUE=12000000
  ICCARM.CCIncludePath2: .\inc; ..\inc; src\calculation; src; src\display
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 1.hex
  ILINK.IlinkOutputFile: 1.out
  ILINK.IlinkIcfFile: stm32f103C8T6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group src
    src/: config_periph.c config_periph.h delay_us_timer.c formula_handling.c keys_functions.c keys_handling.c keys_handling.h main.c main.h stm32f10x_it.c text_functions.c text_functions.h
  group src/Calculation
    src/calculation/: math_defines.h str_math.c str_math.h str_operate.c str_operate.h
  group src/CMSIS
    src/CMSIS/: system_stm32f10x.c
  group src/display
    src/display/: display_handling.c display_handling.h fonts.h lcd_worker.c lcd_worker.h ST7565R.c ST7565R.h
  group src/inc
    src/inc/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.h
  group src/startup
    src/startup/: startup_stm32f10x_md_vl.s
  group src/StdPeriphLib
    src/StdPeriphLib/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
